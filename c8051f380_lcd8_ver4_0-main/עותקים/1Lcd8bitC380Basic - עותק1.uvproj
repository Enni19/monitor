# Keil uVision project 1Lcd8bitC380Basic - עותק1.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F380 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: Lcd8bitC380Basic
  c flags: Optimize=7 SizeSpeed=1
  group Source Group 1
    ./: init380.c main.c SYS19_v2.LIB
